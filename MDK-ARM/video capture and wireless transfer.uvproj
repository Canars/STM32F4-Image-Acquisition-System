# Keil uVision project video capture and wireless transfer.uvproj, settings and files
target ov2640 video capture (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: video capture and wireless transfer +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User\inc;..\GSPI;..\Wifi\Inc;..\Wifi\WLAN;..\Wifi\Api;..\Wifi\IF;..\Wifi\IO;..\uip-1-0\uip;..\uip-1-0\unix;..\uip-1-0\apps\udpclient;..\uip-1-0\apps\dhcps
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/src/: main.c delay.c rm68042.c sccb.c stm32f4xx_it.c dcmi_ov2640.c usart.c flash.c timerx.c
    ../GSPI/: GSPI.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Periph_Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_syscfg.c
  group Wifi_Stack
    ../Wifi/WLAN/: WlanAdapter.c WlanCmd.c WlanHal.c WlanInit.c WlanMisc.c WlanPkt.c
    ../Wifi/Api/: WifiApiExport.c WifiApiPrivate.c WiFiCommand.c
    ../Wifi/IF/: Wifi_If.c
    ../Wifi/IO/: Wifi_Hw.c
  group uIP_1.0
    ../uip-1-0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uIP_APP
    ../uip-1-0/unix/: clock-arch.c tapdev.c
    ../uip-1-0/apps/udpclient/: uIP_App.c udp_client.c
    ../uip-1-0/apps/dhcps/: dhcps.c
